# Keil uVision project Nucleo_rtos_basic.uvprojx, settings and files
target Nucleo_rtos_basic (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F107RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Nucleo_rtos_basic
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STM3210C_EVAL
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -D__ASSERT_MSG -DTARGET_STM32F1 --no_rtti -DTARGET_STM32F107RC -DMBED_BUILD_TIMESTAMP=1484039781.98 -Otime -DDEVICE_PORTINOUT=1 -D__CORTEX_M3 -DTARGET_FF_ARDUINO -c -O3 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DTARGET_RELEASE --split_sections -DARM_MATH_CM3 -DTARGET_LIKE_CORTEX_M3 -DDEVICE_ANALOGIN=1 -DTARGET_NUCLEO_F103RC -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M --cpu=Cortex-M3 -DTARGET_FF_MORPHO -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL=1 -DTARGET_M3 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -D__MBED_CMSIS_RTOS_CM -DTARGET_LIKE_MBED
  c include: ..\mbed;..\mbed\cmsis;..\mbed\drivers;..\mbed\hal;..\mbed\platform;..\mbed\targets\TARGET_STM;..\mbed\targets\TARGET_STM\TARGET_STM32F1;..\mbed\targets\TARGET_STM\TARGET_STM32F1\device;..\mbed\targets\TARGET_STM\TARGET_STM32F1\TARGET_NUCLEO_F103RB;..\mbed\targets\TARGET_STM\TARGET_STM32F1\TARGET_NUCLEO_F103RB\device;..\mbed\targets\TARGET_STM\TARGET_STM32F1\TARGET_NUCLEO_F103RB\device\TOOLCHAIN_ARM_STD;..\mbed-rtos\rtos;..\mbed-rtos\rtx\TARGET_CORTEX_M;..\mbed-rtos\rtx\TARGET_CORTEX_M\TARGET_M3\TOOLCHAIN_ARM;..\user;..\mbed-rtos;..\mbed\features\unsupported\USBDevice\USBSerial;..\mbed\features\unsupported\USBDevice\USBDevice;..\mbed\features\unsupported\USBDevice\USBDevice\TARGET_STM
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M3,-D__CMSIS_RTOS,-DARM_MATH_CM3,-D__MBED_CMSIS_RTOS_CM
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\mbed\targets\TARGET_STM\TARGET_STM32F1\TARGET_NUCLEO_F103RB\device\TOOLCHAIN_ARM_STD\stm32f107xc.sct
  group Nucleo_rtos_basic
    ../user/: main.cpp mbed_config.h
  group TARGET_CORTEX_M
    ../mbed-rtos/rtx/TARGET_CORTEX_M/: HAL_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_OsEventObserver.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c RTX_Conf_CM.c
  group TARGET_NUCLEO_F103RB
    ../mbed/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/: PeripheralPins.c
  group TARGET_STM
    ../mbed/targets/TARGET_STM/: hal_tick_16b.c hal_tick_32b.c i2c_api.c lp_ticker.c rtc_api.c sleep.c stm_spi_api.c trng_api.c us_ticker_16b.c us_ticker_32b.c
  group TARGET_STM32F1
    ../mbed/targets/TARGET_STM/TARGET_STM32F1/: analogin_api.c can_api.c gpio_api.c gpio_irq_api.c mbed_overrides.c pinmap.c port_api.c pwmout_api.c serial_api.c spi_api.c
  group TOOLCHAIN_ARM
    ../mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM/: HAL_CM3.c SVC_Table.S
  group TOOLCHAIN_ARM_STD
    ../mbed/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/device/TOOLCHAIN_ARM_STD/: sys.cpp startup_stm32f107xc.S
  group device
    ../mbed/targets/TARGET_STM/TARGET_STM32F1/device/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_crc.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
    ../mbed/targets/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/device/: cmsis_nvic.c system_stm32f1xx.c
  group drivers
    ../mbed/drivers/: AnalogIn.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CAN.cpp Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp RawSerial.cpp Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp
  group hal
    ../mbed/hal/: mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_ticker_api.c mbed_us_ticker_api.c
  group mbed
    ../mbed/: mbed.h
  group platform
    ../mbed/platform/: mbed_assert.c mbed_board.c mbed_critical.c mbed_error.c mbed_interface.c mbed_mem_trace.c mbed_semihost_api.c mbed_stats.c mbed_wait_api_no_rtos.c CallChain.cpp mbed_alloc_wrappers.cpp mbed_rtc_time.cpp mbed_wait_api_rtos.cpp retarget.cpp
  group rtos
    ../mbed-rtos/rtos/: rtos_idle.c Mutex.cpp RtosTimer.cpp Semaphore.cpp Thread.cpp
  group feature/usbserial
    ../mbed/features/unsupported/USBDevice/USBSerial/: USBCDC.cpp USBSerial.cpp
  group feature/usbdevice
    ../mbed/features/unsupported/USBDevice/USBDevice/: USBDevice.cpp
    ../mbed/features/unsupported/USBDevice/USBDevice/TARGET_STM/: USBHAL_STM32.cpp
